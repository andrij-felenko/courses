#include <iostream>
#include <cstdint>
#include <cassert>

// 1. Безпечне модульне множення з 128-бітним проміжним типом
// Ця функція гарантує, що a * b ніколи не спричинить втрату даних через overflow.
uint64_t mul_mod(uint64_t a, uint64_t b, uint64_t m) {
    // Приведення до unsigned __int128 перед множенням розширює розрядність.
    // Залишок від ділення завжди буде меншим за m, тому ми можемо безпечно 
    // повернути результат до uint64_t.
    return static_cast<uint64_t>((static_cast<unsigned __int128>(a) * b) % m);
}

// 2. Основний алгоритм швидкого піднесення до степеня (Right-to-Left)
// Обчислює (base^exp) % mod за час O(log exp).
uint64_t mod_exp(uint64_t base, uint64_t exp, uint64_t mod) {
    if (mod == 1) return 0; // Запобіжник: залишок від ділення на 1 завжди 0
    
    uint64_t result = 1;
    base = base % mod;      // Початкова нормалізація основи для безпеки
    
    while (exp > 0) {
        // Перевіряємо наймолодший біт показника степеня (число непарне?)
        if (exp % 2 == 1) {
            // Якщо біт == 1, акумулюємо поточну основу в загальний результат
            result = mul_mod(result, base, mod);
        }
        // Незалежно від поточного біта, підносимо основу до квадрата.
        // Це формує послідовність a, a^2, a^4, a^8, a^16...
        base = mul_mod(base, base, mod);
        
        // Зсуваємо біти степеня вправо (цілочисельне ділення на 2), 
        // відкидаючи вже оброблений наймолодший біт.
        exp /= 2;
    }
    
    return result;
}

// 3. Архітектурний шаблон розширення: Монтгомері (Montgomery reduction)
// Для криптографічних протоколів високої навантаженості операція ділення 
// у mul_mod є дуже дорогою. Зазвичай її замінюють на алгебру Монтгомері.
struct MontgomeryCtx {
    uint64_t m;      // Модуль
    uint64_t m_prime; // m' для швидкої редукції
    uint64_t r_sq;    // R^2 mod m
    // Внутрішній контекст для майбутньої заміни повільного ділення.
};

// 4. Функція юніт-тестів, що верифікує граничні та класичні випадки
void run_tests() {
    // Тест 1: Класичний шкільний приклад
    // 3^5 mod 7 = 243 mod 7 = 5
    assert(mod_exp(3, 5, 7) == 5);
    std::cout << "Test 1 (Basic) PASSED" << std::endl;
    
    // Тест 2: Використання великих чисел для перевірки відсутності overflow
    uint64_t a = 98765432101234567ULL;
    uint64_t b = 12345678909876543ULL;
    uint64_t m = 1000000000000000000ULL; // 10^18
    uint64_t res = mod_exp(a, b, m);
    
    std::cout << "Test 2 (Large ints): mod_exp(a, b, m) = " << res << std::endl;
    assert(res > 0); // Переконуємось, що не відбулося повного обнулення через помилки
    std::cout << "All tests successfully executed!" << std::endl;
}

// 5. Головна точка входу в програму
int main() {
    run_tests();
    return 0;
}
