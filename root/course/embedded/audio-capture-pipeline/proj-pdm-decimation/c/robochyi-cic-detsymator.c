#include <stdint.h>

#define CIC_N   3           // порядок: 3 інтегратори + 3 гребінки
#define CIC_D   64          // коефіцієнт проріджування (OSR)

// Стан живе МІЖ блоками, тому статичний.
// Інтегратори — беззнакові: загортання по модулю визначене стандартом,
// а гребінка на виході однаково бере правильну різницю.
static uint32_t integ[CIC_N];        // накопичувачі інтеграторів
static uint32_t comb_prev[CIC_N];    // затримка на 1 у кожній гребінці

// Проганяє блок PDM-байтів крізь CIC-дециматор. Кладе PCM у out.
// Повертає кількість відліків PCM.
int pdm_decimate_cic(const uint8_t *pdm, int nbytes, int16_t *out) {
    int8_t bits[8];
    int    phase = 0;        // лічильник до D: коли доходить до D — беремо відлік
    int    nout  = 0;

    for (int i = 0; i < nbytes; i++) {
        pdm_unpack_byte(pdm[i], bits);
        for (int k = 0; k < 8; k++) {
            // ── частина 1: інтегратори на ПОВНІЙ швидкості f_pdm ──
            // вхід — біполярний біт ±1, розширений до 32 біт
            uint32_t v = (uint32_t)(int32_t)bits[k];
            integ[0] += v;
            for (int s = 1; s < CIC_N; s++)
                integ[s] += integ[s - 1];   // кожен інтегрує попередній

            // ── проріджування ÷D: більшість тактів просто пропускаємо ──
            if (++phase < CIC_D)
                continue;
            phase = 0;

            // ── частина 2: гребінки на НИЗЬКІЙ швидкості f_s ──
            // працюють лише раз на D тактів — тут, після проріджування
            uint32_t c = integ[CIC_N - 1];  // вихід останнього інтегратора
            for (int s = 0; s < CIC_N; s++) {
                uint32_t d = c - comb_prev[s];   // різниця з відкладеним
                comb_prev[s] = c;                // запам'ятали для наступного разу
                c = d;                           // передали далі по каскаду
            }

            // ── масштаб: прибрати підсилення D^N зсувом праворуч ──
            // повне підсилення = D^N; log2(D^N) = N·log2(D) = 3·6 = 18 біт
            int32_t y = (int32_t)c >> (CIC_N * 6);   // >>18 для D=64, N=3

            // насичення в int16 (після ідеального фільтра рідко, але чесно)
            if (y >  32767) y =  32767;
            if (y < -32768) y = -32768;
            out[nout++] = (int16_t)y;
        }
    }
    return nout;
}
