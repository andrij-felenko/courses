// Рівень сигналу ПІСЛЯ поточного підсилення. Реалізацію RMS беремо з теми
// (сума квадратів у широкому типі, корінь раз на кадр); тут — лише виклик.
static float measure_level(const int16_t *buf, int n, float gain);

// Один крок зчепленого AGC. voice — прапорець від сторожа (vad_feed/vad_poll).
void agc_vad_process(agc_vad_t *s, int16_t *buf, int n, bool voice)
{
    // ── 1. Керування режимом: голос заряджає утримання; тиша його точить. ──
    if (voice) {
        s->hold   = s->hold_frames;    // є голос → повний заряд утримання
        s->frozen = false;             //           і точно не заморожені
    } else if (s->hold > 0) {
        s->hold--;                     // тиша, але утримання ще тримає петлю живою
        if (s->hold == 0)
            s->frozen = true;          // утримання вичерпано → заморозка
    }
    // (якщо !voice і hold уже 0 — лишаємось замороженими, нічого не робимо)

    // ── 2. Ведення підсилення — ТІЛЬКИ поки не заморожені. ──
    if (!s->frozen) {
        float level = measure_level(buf, n, s->gain);   // рівень після підсилення
        if (level > 1.0f) {                             // не ділити на нуль на тиші
            float want = s->gain * (s->target / level); // куди хотіли б прийти
            if (want > s->max_gain) want = s->max_gain; // стеля

            // Напрямок: вниз (want<gain) — атака (швидко); вгору — відпускання (повільно).
            bool going_up = (want > s->gain);

            // ШУМОВИЙ ПОРІГ: угору піднімаємо лише якщо рівень вартий того.
            // Нижче гейта — підйом заборонено (там шум, а не голос).
            if (going_up && level < s->gate_level)
                want = s->gain;                         // тримати, не піднімати

            float a = going_up ? s->a_rel : s->a_atk;   // вгору повільно, вниз швидко
            s->gain += a * (want - s->gain);            // повземо до цілі
        }
    }

    // ── 3. Застосувати підсилення до буфера з насиченням (завжди, навіть у заморозці:
    //       заморожений gain теж треба накласти). Гарячий цикл — цілий. ──
    for (int i = 0; i < n; i++) {
        int32_t y = (int32_t)(buf[i] * s->gain);
        if (y >  32767) y =  32767;
        if (y < -32768) y = -32768;
        buf[i] = (int16_t)y;
    }
}
