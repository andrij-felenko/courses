#define N      64                 // довжина адаптивного фільтра — СТЕПІНЬ ДВІЙКИ
#define NMASK  (N - 1)            // маска для обмотки індексу (працює лише для 2^k)

static float w[N]  = {0};         // коефіцієнти бойового фільтра — те, що вчимо
static float xr[N] = {0};         // кільце опорного шуму x[n]
static float xs[N] = {0};         // кільце filtered-x (опорний крізь Ŝ)
static int   head  = 0;           // куди класти наступний відлік (спільний для xr, xs)

// один бойовий такт FxLMS на кільцевих буферах. Повертає анти-шум у ЦАП.
static float fxlms_step(float ref, float err)
{
    // 1) спершу прожену опорний крізь копію вторинного шляху → filtered-x.
    //    Це теж згортка (Ŝ ⊛ x), і їй потрібне СВОЄ вікно опорного.
    //    Щоб не тримати третій буфер, рахуємо x′ просто тут, по кільцю xr.
    float xprime = 0.0f;
    for (int i = 0; i < M; ++i) {
        int idx = (head - 1 - i) & NMASK;     // i-й за давниною опорний
        xprime += s_hat[i] * xr[idx];
    }

    // 2) кладемо нові відліки в кільця (O(1): одне присвоєння, без зсуву)
    xr[head] = ref;
    xs[head] = xprime;
    head = (head + 1) & NMASK;                 // посунули по колу

    // 3) анти-шум = згортка опорного з поточними коефіцієнтами:
    //    w[0]·(найновіший) + w[1]·(попередній) + …
    float y = 0.0f;
    for (int i = 0; i < N; ++i) {
        int idx = (head - 1 - i) & NMASK;
        y += w[i] * xr[idx];
    }

    // 4) навчання: кожен коеф. тягнемо кроком ∝ err · (filtered-x тієї ж давнини)
    const float mu = 0.02f;
    for (int i = 0; i < N; ++i) {
        int idx = (head - 1 - i) & NMASK;
        w[i] += mu * err * xs[idx];
    }

    return y;                                   // піде в ЦАП → динамік (анти-шум)
}
