#include <stdint.h>
#include <stdbool.h>

// Звертання до сервера видачі — по мережі (HTTP/сокет); тут за фасадом.
// Повертають true за успіху. reserve заповнює *out_serial.
bool srv_reserve(const char *station, uint32_t *out_serial);
bool srv_confirm(const char *station, uint32_t serial);

// Дії над платою на стенді (голки притиснуті).
bool board_flash_serial(uint32_t serial);   // зашити номер у розділ даних
bool board_verify(uint32_t serial);         // прочитати назад + самотест плати

// Один цикл провізіонування однієї плати. Повертає true, якщо плата готова.
bool provision_one_board(const char *station) {
    uint32_t serial;

    // ── ФАЗА 1: зарезервувати номер У БАЗІ, ПЕРШ НІЖ чіпати плату ──
    if (!srv_reserve(station, &serial)) {
        report_fault("не вдалося зарезервувати серійник");
        return false;                 // номера нема — плату не чіпаємо взагалі
    }

    // ── НЕОБОРОТНА ДІЯ: зашити номер у Flash плати ──
    // Строго МІЖ резервом і підтвердженням. Якщо тут обірветься живлення —
    // номер лишиться 'reserved' у базі, прибиральник спише його в пропуск.
    if (!board_flash_serial(serial)) {
        // Зашити не вдалося. Резерв лишаємо серверу відкотити по таймауту —
        // НЕ намагаємось 'звільнити' номер: ми не певні, чи щось лягло в плату.
        report_fault("зашивання не вдалося; резерв відкотиться сам");
        return false;
    }

    // ── ЗВІРКА: прочитати назад і дати платі підтвердити, що бачить себе ──
    if (!board_verify(serial)) {
        report_fault("звірка не зійшлася; резерв відкотиться сам");
        return false;                 // так само НЕ підтверджуємо
    }

    // ── ФАЗА 2: усе зійшлося — підтвердити видачу ──
    // Тільки тут номер стає 'used'. Плата офіційно поїхала з цим номером.
    if (!srv_confirm(station, serial)) {
        // Резерв протух (прибиральник випередив?) — плата зашита, та не закріплена.
        // У брак/переробку під новий номер: закріпити протухле НЕ можна.
        report_fault("не вдалося підтвердити; плату на переробку");
        return false;
    }

    return true;                      // плата готова: номер зашитий і закріплений
}
