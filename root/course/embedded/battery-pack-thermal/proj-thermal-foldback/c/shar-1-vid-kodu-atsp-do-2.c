// Вузли таблиці опір→температура для конкретного NTC (напр. 10 кОм, β≈3950).
// Опір спадає з температурою, тож таблиця впорядкована за спаданням опору.
// Температура — в десятих градуса Цельсія (щоб не тягнути float).
typedef struct { int32_t ohm; int16_t t_c10; } ntc_point_t;

static const ntc_point_t NTC_TAB[] = {
    { 96358, -200 },  // -20.0 °C
    { 55046, -100 },  // -10.0 °C
    { 32554,    0 },  //   0.0 °C
    { 19873,  100 },  //  10.0 °C
    { 12488,  200 },  //  20.0 °C
    { 10000,  250 },  //  25.0 °C  (опорна точка)
    {  8059,  300 },  //  30.0 °C
    {  5327,  400 },  //  40.0 °C
    {  3603,  500 },  //  50.0 °C
    {  2488,  600 },  //  60.0 °C
    {  1751,  700 },  //  70.0 °C
};
#define NTC_TAB_N  (int)(sizeof(NTC_TAB) / sizeof(NTC_TAB[0]))

// Опір (Ом) → температура (десяті °C) лінійною інтерполяцією за таблицею.
// Повертає INT16_MIN як ознаку «поза таблицею / неможливе значення».
int16_t ohm_to_c10(int32_t ohm) {
    if (ohm <= 0) return INT16_MIN;                  // КЗ або хибний нуль

    // вище за найбільший опір у таблиці — холодніше за нижній край
    if (ohm >= NTC_TAB[0].ohm)            return NTC_TAB[0].t_c10;
    // нижче за найменший опір — гарячіше за верхній край
    if (ohm <= NTC_TAB[NTC_TAB_N - 1].ohm) return NTC_TAB[NTC_TAB_N - 1].t_c10;

    // знайти сусідні вузли, між якими лежить опір (таблиця спадна за опором)
    for (int i = 0; i < NTC_TAB_N - 1; i++) {
        int32_t r_hi = NTC_TAB[i].ohm;       // більший опір (холодніше)
        int32_t r_lo = NTC_TAB[i + 1].ohm;   // менший опір (гарячіше)
        if (ohm <= r_hi && ohm >= r_lo) {
            int32_t t_hi = NTC_TAB[i].t_c10;     // нижча температура
            int32_t t_lo = NTC_TAB[i + 1].t_c10; // вища температура
            // лінійна інтерполяція: чим ближче опір до r_lo, тим гарячіше
            int32_t span_r = r_hi - r_lo;
            int32_t span_t = t_lo - t_hi;
            return (int16_t)(t_hi + (r_hi - ohm) * span_t / span_r);
        }
    }
    return INT16_MIN;   // сюди не дійти, але хай компілятор спить спокійно
}
