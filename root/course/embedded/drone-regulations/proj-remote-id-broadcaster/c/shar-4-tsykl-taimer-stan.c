// Скільки часу між кадрами. 1 Гц — базова вимога стандарту; на «нестандартних»
// каналах стандарт вимагає 5 Гц (200 мс). Беремо безпечніші 200 мс.
#define RID_PERIOD_MS   200

// Фікс вважаємо застарілим, якщо він старший за це: тоді знову мовимо «невідомо».
#define FIX_STALE_MS    2000

// Глобальний (для прикладу) стан мовника.
static gps_fix_t g_fix;                 // останній відомий фікс
static uint32_t  g_last_fix_ms;         // мить приходу останнього фіксу за НАШИМ годинником
static uint32_t  g_last_tx_ms;          // коли востаннє відправили пакет
static char      g_uas_id[ODID_ID_LEN + 1];
static char      g_operator_id[ODID_ID_LEN + 1];

// Викликається парсером GPS щоразу, коли прийшов свіжий фікс.
// (Парсинг рядків NMEA/UBX — окрема тема; сюди приходить уже готовий fix.)
// Разом із фіксом парсер передає й поточний час millis() — щоб мовник запам'ятав
// не лише координати, а й МИТЬ їхнього приходу: від неї він сам лічитиме вік.
void rid_on_gps_fix(uint32_t now_ms, const gps_fix_t *fix) {
    g_fix         = *fix;               // найсвіжіші координати
    g_last_fix_ms = now_ms;             // жива опорна точка для віку фіксу
}

// Головний тик мовника: кличемо часто (напр. щоцикл super-loop).
// now_ms — поточний час у мілісекундах (millis()).
void rid_tick(uint32_t now_ms) {
    // 1) Чи час відправляти? Якщо інтервал ще не минув — виходимо миттєво.
    if ((uint32_t)(now_ms - g_last_tx_ms) < RID_PERIOD_MS)
        return;
    g_last_tx_ms = now_ms;

    // 2) Визначаємо стан «є фікс / нема фіксу» на ЦЮ мить.
    //    Фікс дійсний, лише якщо він валідний І не застарів.
    //    Знімок координат і опорну мить приходу беремо поряд — щоб вік
    //    міряти саме цьому фіксові, а не змішати старі дані зі свіжою міткою.
    gps_fix_t snap   = g_fix;           // знімок координат (переривання не змінить по ходу)
    uint32_t  fix_ms = g_last_fix_ms;   // ...і мить приходу цього ж фіксу

    // Справжній вік = яким фікс був на мить парсингу (fix_age_ms) ПЛЮС скільки
    // минуло від приходу дотепер. Другий доданок — саме те, чого застигле поле
    // fix_age_ms не рахує, тому додаємо його руками, від нашої опорної мітки.
    uint32_t age = snap.fix_age_ms + (uint32_t)(now_ms - fix_ms);
    if (!snap.valid || age > FIX_STALE_MS)
        snap.valid = 0;                 // застарілий фікс = наче нема фіксу (чесність!)

    // 3) Збираємо пакет із поточного стану.
    uint8_t buf[3 + ODID_PACK_MAX * ODID_MSG_SIZE];
    int len = build_pack(buf, sizeof(buf), g_uas_id, g_operator_id, &snap);
    if (len <= 0)
        return;                         // пакет не зібрався — пропускаємо цикл, не падаємо

    // 4) Віддаємо в ефір. Ця функція — вивідка драйвера радіо:
    //    вона кладе байти в BLE-рекламу або Wi-Fi NAN/beacon. Нам байдуже, як саме.
    radio_broadcast(buf, len);
}
