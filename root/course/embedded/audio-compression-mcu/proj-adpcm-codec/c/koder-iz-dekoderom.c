static const int16_t step_table[89] = {
    7,     8,     9,     10,    11,    12,    13,    14,    16,    17,
    19,    21,    23,    25,    28,    31,    34,    37,    41,    45,
    50,    55,    60,    66,    73,    80,    88,    97,    107,   118,
    130,   143,   157,   173,   190,   209,   230,   253,   279,   307,
    337,   371,   408,   449,   494,   544,   598,   658,   724,   796,
    876,   963,   1060,  1166,  1282,  1411,  1552,  1707,  1878,  2066,
    2272,  2499,  2749,  3024,  3327,  3660,  4026,  4428,  4871,  5358,
    5894,  6484,  7132,  7845,  8630,  9493,  10442, 11487, 12635, 13899,
    15289, 16818, 18500, 20350, 22385, 24623, 27086, 29794, 32767
};

static const int8_t index_table[16] = {
    -1, -1, -1, -1,  2,  4,  6,  8,   // коди 0..7 (біт знаку = 0)
    -1, -1, -1, -1,  2,  4,  6,  8    // коди 8..15 (біт знаку = 1) — те саме
};

// Кодує ОДИН 16-бітний відлік у 4-бітний код і оновлює стан рівно так,
// як це зробить декодер (тому кодер і декодер лишаються синхронні).
static uint8_t adpcm_encode_sample(adpcm_state *s, int16_t sample) {
    int32_t step = step_table[s->index];
    int32_t diff = (int32_t)sample - s->predict;   // різниця з передбаченням

    uint8_t code = 0;
    if (diff < 0) {           // знак — старший (4-й) біт коду
        code = 8;
        diff = -diff;         // далі працюємо з модулем різниці
    }

    // Квантуємо |diff| у 3 біти величини, порівнюючи з step, step/2, step/4.
    // Це зворотне до декодера: там ми з бітів СКЛАДАЛИ внесок, тут — РОЗБИРАЄМО.
    int32_t t = step;
    if (diff >= t) { code |= 4; diff -= t; }   // біт «×1»
    t >>= 1;
    if (diff >= t) { code |= 2; diff -= t; }   // біт «×1/2»
    t >>= 1;
    if (diff >= t) { code |= 1; }              // біт «×1/4»

    // --- ДЕКОДЕР УСЕРЕДИНІ КОДЕРА ---
    // Тим самим кодом, що щойно склали, відновлюємо внесок ТОЧНО за формулою
    // декодера — і оновлюємо predict рівно на те число, яке буде в декодера.
    int32_t vpdiff = step >> 3;                 // базовий внесок (step/8)
    if (code & 4) vpdiff += step;
    if (code & 2) vpdiff += step >> 1;
    if (code & 1) vpdiff += step >> 2;
    if (code & 8) s->predict -= vpdiff;
    else          s->predict += vpdiff;

    // обрізаємо оцінку в 16-бітний діапазон (пастка переповнення!)
    if (s->predict >  32767) s->predict =  32767;
    if (s->predict < -32768) s->predict = -32768;

    // адаптуємо крок за таблицею й тримаємо індекс у межах 0..88
    s->index += index_table[code];
    if (s->index < 0)  s->index = 0;
    if (s->index > 88) s->index = 88;

    return code & 0x0f;   // повертаємо рівно 4 біти
}
