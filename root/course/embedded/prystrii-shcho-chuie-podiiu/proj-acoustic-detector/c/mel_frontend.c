#include "mel_frontend.h"

#include <string.h>

#include "fft_q15.h"

/* Коефіцієнт преакценту 0.95 у Q15: підіймає верх спектра, який у мовному
 * й ударному звуці на 6 дБ/октаву тихіший за низ. */
#define PRE_EMPHASIS_Q15   31130

/* Зсув, що переводить log2 потужності в шкалу int8_t.
 * Одиниця ознаки = 1/4 октави за потужністю ≈ 0.75 дБ. */
#define LOG_OFFSET_Q2      64

/* Вікно Хеммінга на 256 відліків у Q15 (512 байтів Flash). */
static const int16_t HAMMING_Q15[AED_FRAME_SAMPLES] = {
     2621,  2626,  2640,  2663,  2695,  2736,  2786,  2845,
     2913,  2991,  3077,  3172,  3276,  3388,  3509,  3639,
     3778,  3925,  4080,  4243,  4415,  4595,  4782,  4978,
     5181,  5392,  5610,  5836,  6069,  6309,  6555,  6809,
     7069,  7336,  7609,  7888,  8173,  8464,  8760,  9062,
     9369,  9681,  9998, 10319, 10646, 10976, 11310, 11649,
    11991, 12336, 12685, 13037, 13391, 13749, 14108, 14470,
    14834, 15199, 15566, 15935, 16304, 16674, 17045, 17416,
    17788, 18159, 18530, 18900, 19270, 19639, 20007, 20373,
    20738, 21101, 21461, 21820, 22176, 22529, 22879, 23226,
    23570, 23910, 24247, 24579, 24907, 25231, 25551, 25865,
    26175, 26479, 26778, 27072, 27360, 27642, 27918, 28188,
    28451, 28708, 28958, 29202, 29438, 29667, 29889, 30104,
    30311, 30510, 30702, 30886, 31061, 31229, 31388, 31539,
    31682, 31816, 31942, 32059, 32167, 32266, 32357, 32439,
    32511, 32575, 32630, 32675, 32712, 32739, 32758, 32767,
    32767, 32758, 32739, 32712, 32675, 32630, 32575, 32511,
    32439, 32357, 32266, 32167, 32059, 31942, 31816, 31682,
    31539, 31388, 31229, 31061, 30886, 30702, 30510, 30311,
    30104, 29889, 29667, 29438, 29202, 28958, 28708, 28451,
    28188, 27918, 27642, 27360, 27072, 26778, 26479, 26175,
    25865, 25551, 25231, 24907, 24579, 24247, 23910, 23570,
    23226, 22879, 22529, 22176, 21820, 21461, 21101, 20738,
    20373, 20007, 19639, 19270, 18900, 18530, 18159, 17788,
    17416, 17045, 16674, 16304, 15935, 15566, 15199, 14834,
    14470, 14108, 13749, 13391, 13037, 12685, 12336, 11991,
    11649, 11310, 10976, 10646, 10319,  9998,  9681,  9369,
     9062,  8760,  8464,  8173,  7888,  7609,  7336,  7069,
     6809,  6555,  6309,  6069,  5836,  5610,  5392,  5181,
     4978,  4782,  4595,  4415,  4243,  4080,  3925,  3778,
     3639,  3509,  3388,  3276,  3172,  3077,  2991,  2913,
     2845,  2786,  2736,  2695,  2663,  2640,  2626,  2621
};

/* Межі 32 трикутників мел-банку в комірках FFT: рівномірна сітка в мел-шкалі
 * від 64 Гц до 7600 Гц. Трикутник m займає комірки MEL_EDGES[m]…MEL_EDGES[m+2]
 * з вершиною в MEL_EDGES[m+1] — сусідні смуги перекриваються наполовину. */
static const uint16_t MEL_EDGES[AED_MEL_BINS + 2] = {
      2,    3,    5,    7,   10,   12,   15,   18,   21,   24,
     27,   31,   35,   40,   44,   49,   55,   61,   67,   74,
     81,   89,   97,  106,  116,  126,  137,  149,  162,  176,
    191,  207,  224,  243
};

/* Робочі масиви FFT — у .bss, а не на стеку: 2 КБ на стек задачі RTOS
 * ставити не варто, а стек переривання таких розмірів просто не має. */
static int16_t fft_re[AED_FFT_SIZE];
static int16_t fft_im[AED_FFT_SIZE];

/* log2(v) у Q8. Ціла частина — позиція старшого одиничного біта,
 * дробова — лінійна апроксимація log2(1+x) ≈ x за мантисою.
 * Похибка апроксимації не перевищує 0.086 біта (≈ 0.26 дБ) — на порядок
 * менша за крок квантування ознаки, тож ряду Тейлора тут не треба. */
static int32_t log2_q8(uint64_t v)
{
    if (v == 0) {
        return 0;
    }

    const int msb = 63 - __builtin_clzll(v);
    uint32_t frac;

    if (msb >= 8) {
        frac = (uint32_t)((v >> (msb - 8)) & 0xFFu);
    } else {
        frac = (uint32_t)((v << (8 - msb)) & 0xFFu);
    }

    return ((int32_t)msb << 8) + (int32_t)frac;
}

void mel_frontend_frame(int16_t *pre_state, const int16_t *frame, int8_t *out_mel)
{
    /* 1. Преакцент і вікно. Хвіст FFT добиваємо нулями. */
    for (unsigned i = 0; i < AED_FRAME_SAMPLES; ++i) {
        int32_t pre = (int32_t)frame[i] - (((int32_t)(*pre_state) * PRE_EMPHASIS_Q15) >> 15);
        *pre_state = frame[i];

        if (pre > 32767) {
            pre = 32767;
        } else if (pre < -32768) {
            pre = -32768;
        }

        fft_re[i] = (int16_t)((pre * (int32_t)HAMMING_Q15[i]) >> 15);
        fft_im[i] = 0;
    }
    memset(&fft_re[AED_FRAME_SAMPLES], 0,
           (AED_FFT_SIZE - AED_FRAME_SAMPLES) * sizeof(fft_re[0]));
    memset(&fft_im[AED_FRAME_SAMPLES], 0,
           (AED_FFT_SIZE - AED_FRAME_SAMPLES) * sizeof(fft_im[0]));

    /* 2. Спектр. Далі потрібна лише перша половина: сигнал дійсний,
     *    і другу половину дзеркалить симетрія. */
    fft_q15_512(fft_re, fft_im);

    /* 3. Трикутні мел-смуги по квадрату модуля. */
    for (unsigned m = 0; m < AED_MEL_BINS; ++m) {
        const unsigned lo  = MEL_EDGES[m];
        const unsigned mid = MEL_EDGES[m + 1];
        const unsigned hi  = MEL_EDGES[m + 2];

        uint64_t acc = 0;

        for (unsigned b = lo; b < mid; ++b) {
            const int32_t w = (int32_t)(((b - lo) << 15) / (mid - lo));
            acc += ((uint64_t)fft_q15_power(fft_re[b], fft_im[b]) * (uint32_t)w) >> 15;
        }
        for (unsigned b = mid; b < hi; ++b) {
            const int32_t w = (int32_t)(((hi - b) << 15) / (hi - mid));
            acc += ((uint64_t)fft_q15_power(fft_re[b], fft_im[b]) * (uint32_t)w) >> 15;
        }

        /* 4. Логарифм і квантування. Порожня смуга (тиша нижче молодшого
         *    біта після поділів у FFT) осідає на дно шкали. */
        int32_t q = (acc == 0) ? -128 : ((log2_q8(acc) >> 6) - LOG_OFFSET_Q2);

        if (q > 127) {
            q = 127;
        } else if (q < -128) {
            q = -128;
        }

        out_mel[m] = (int8_t)q;
    }
}
