#include <stdint.h>

/* Угода про біти: біт i числа (значення 1u<<i) ↔ позиція i+1 кодового слова.
   Контрольні позиції 1,2,4 → біти 0,1,3; дані (3,5,6,7) → біти 2,4,5,6. */
static const uint8_t MASK[3] = { 0x55, 0x66, 0x78 };  /* групи p1, p2, p4 */
static const uint8_t PPOS[3] = { 0, 1, 3 };           /* куди лягає кожен parity */

static int parity8(uint8_t x) {              /* XOR усіх бітів байта */
    x ^= x >> 4;  x ^= x >> 2;  x ^= x >> 1;
    return x & 1;
}

uint8_t ham74_encode(uint8_t data) {         /* 4 біти даних → 7-бітне слово */
    uint8_t w = 0;
    w |= (data & 1) << 2;                     /* d1 → позиція 3 */
    w |= ((data >> 1) & 1) << 4;              /* d2 → позиція 5 */
    w |= ((data >> 2) & 1) << 5;              /* d3 → позиція 6 */
    w |= ((data >> 3) & 1) << 6;              /* d4 → позиція 7 */
    for (int k = 0; k < 3; k++)               /* parity = парність своєї групи */
        w |= parity8(w & MASK[k]) << PPOS[k];
    return w;
}

uint8_t ham74_decode(uint8_t w, int *fixed) {  /* 7 біт → 4 біти даних */
    int s = 0;
    for (int k = 0; k < 3; k++)               /* три перевірки складають синдром */
        s |= parity8(w & MASK[k]) << k;
    if (s) w ^= 1u << (s - 1);                /* синдром = адреса; перевертаємо біт */
    if (fixed) *fixed = (s != 0);             /* чи довелося лагодити */
    return  ((w >> 2) & 1)        | (((w >> 4) & 1) << 1)   /* збираємо дані */
          | (((w >> 5) & 1) << 2) | (((w >> 6) & 1) << 3);  /* з позицій 3,5,6,7 */
}
