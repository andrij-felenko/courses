#include <stdio.h>

// Розв'язання лінійної системи A·x = b методом Гаусса з частковим вибором
// головного елемента (n рівнянь, n невідомих). A руйнується на місці.
// Повертає 0, якщо матриця вироджена (singular) — як це робить симулятор.
static double dabs(double v) { return v < 0 ? -v : v; }

static int gauss_solve(int n, double A[][8], double b[], double x[])
{
    for (int col = 0; col < n; ++col) {
        // вибір головного елемента: найбільший за модулем у стовпці
        int piv = col;
        for (int r = col + 1; r < n; ++r)
            if (dabs(A[r][col]) > dabs(A[piv][col]))
                piv = r;
        if (dabs(A[piv][col]) < 1e-15) return 0;   // вироджена матриця
        // переставити рядки piv та col (і праву частину)
        for (int c = 0; c < n; ++c) { double t = A[col][c]; A[col][c] = A[piv][c]; A[piv][c] = t; }
        { double t = b[col]; b[col] = b[piv]; b[piv] = t; }
        // виключити змінну col з усіх інших рядків
        for (int r = 0; r < n; ++r) {
            if (r == col) continue;
            double f = A[r][col] / A[col][col];
            for (int c = col; c < n; ++c) A[r][c] -= f * A[col][c];
            b[r] -= f * b[col];
        }
    }
    for (int i = 0; i < n; ++i) x[i] = b[i] / A[i][i];   // діагональ → розв'язок
    return 1;
}

int main(void)
{
    // Вузли: 0 = a, 1 = b. Земля — опорна, у матриці її немає.
    const int n = 2;
    double G[8][8] = {{0}};     // матриця провідностей (См)
    double I[8]    = {0};       // права частина: струми, що ВТІКАЮТЬ у вузли (А)
    double V[8]    = {0};

    const double R1 = 2e3, R3 = 3e3;   // Ом
    const double Iin = 6e-3;           // А, джерело струму у вузол a
    const double E  = 3.0;             // В, джерело напруги між a і b (плюс до a)

    // ── стампи гілок на землю: лишають +g лише на діагоналі свого вузла ──
    G[0][0] += 1.0 / R1;        // R1: a → земля
    G[1][1] += 1.0 / R3;        // R3: b → земля
    // (якби між a і b стояв РЕЗИСТОР g_ab, тут був би повний стамп:
    //  G[0][0]+=g_ab; G[1][1]+=g_ab; G[0][1]-=g_ab; G[1][0]-=g_ab; )

    // ── стамп джерела струму: +I у рядок правої частини того вузла ──
    I[0] += Iin;                // 6 мА втікає у вузол a

    // На цьому етапі рядки a і b були б готові, АЛЕ між ними — ідеальне E.
    // Робимо дві операції суперузла прямо над матрицею:

    // 1) СКЛЕЮВАННЯ: рядок a ← рядок a + рядок b  (баланс суперузла).
    //    Спільної гілки тут і немає, тож складаються самі зовнішні провідності
    //    та зовнішні струми — рядок стає рівнянням  g1·V_a + g3·V_b = Iin.
    for (int c = 0; c < n; ++c) G[0][c] += G[1][c];
    I[0] += I[1];

    // 2) ОБМЕЖЕННЯ: звільнений рядок b ← рівняння джерела  V_a − V_b = E.
    G[1][0] = +1.0;  G[1][1] = -1.0;  I[1] = E;

    if (!gauss_solve(n, G, I, V)) { printf("singular matrix\n"); return 1; }

    printf("V_a = %.3f В,  V_b = %.3f В\n", V[0], V[1]);   // -> 8.400, 5.400
    return 0;
}
