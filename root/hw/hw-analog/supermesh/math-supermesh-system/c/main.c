#include <stdio.h>

// Розв'язання лінійної системи A·x = b методом Гаусса з частковим вибором
// головного елемента (n рівнянь, n невідомих). A руйнується на місці.
// Повертає 0, якщо матриця вироджена (singular) — як це робить симулятор.
static double dabs(double v) { return v < 0 ? -v : v; }

static int gauss_solve(int n, double A[][8], double b[], double x[])
{
    for (int col = 0; col < n; ++col) {
        // вибір головного елемента: найбільший за модулем у стовпці
        int piv = col;
        for (int r = col + 1; r < n; ++r)
            if (dabs(A[r][col]) > dabs(A[piv][col]))
                piv = r;
        if (dabs(A[piv][col]) < 1e-15) return 0;   // вироджена матриця
        // переставити рядки piv та col (і праву частину)
        for (int c = 0; c < n; ++c) { double t = A[col][c]; A[col][c] = A[piv][c]; A[piv][c] = t; }
        { double t = b[col]; b[col] = b[piv]; b[piv] = t; }
        // виключити змінну col з усіх інших рядків
        for (int r = 0; r < n; ++r) {
            if (r == col) continue;
            double fct = A[r][col] / A[col][col];
            for (int c = col; c < n; ++c) A[r][c] -= fct * A[col][c];
            b[r] -= fct * b[col];
        }
    }
    for (int i = 0; i < n; ++i) x[i] = b[i] / A[i][i];   // діагональ → розв'язок
    return 1;
}

int main(void)
{
    // Вікна: 0 = ліве (I₁), 1 = праве (I₂). Обидва контурні струми за годинниковою.
    const int n = 2;
    double R[8][8] = {{0}};     // матриця контурних опорів (Ом)
    double V[8]    = {0};       // права частина: ЕРС у кільці вікна (В)
    double I[8]    = {0};

    const double R1 = 100.0, R3 = 300.0;   // Ом
    const double Vsrc = 12.0;              // В, джерело напруги в кільці лівого вікна
    const double J    = 20e-3;             // А, джерело струму на спільній гілці (за I₁)

    // ── стампи резисторів власних гілок: +R лише на діагональ свого вікна ──
    R[0][0] += R1;              // R1 — тільки ліве вікно
    R[1][1] += R3;              // R3 — тільки праве вікно
    // (якби спільну гілку займав РЕЗИСТОР R_s, тут був би повний стамп:
    //  R[0][0]+=Rs; R[1][1]+=Rs; R[0][1]-=Rs; R[1][0]-=Rs; )

    // ── стамп джерела напруги: +V у праву частину того вікна, де воно в кільці ──
    V[0] += Vsrc;               // 12 В жене струм у лівому вікні

    // На цьому етапі рядки вікон були б готові, АЛЕ спільну гілку займає
    // джерело струму: у кожному рядку висить невідома напруга U на ньому.
    // Робимо дві операції супер-чарунки прямо над матрицею:

    // 1) СКЛЕЮВАННЯ: рядок I₁ ← рядок I₁ + рядок I₂  (закон напруг супер-чарунки).
    //    Доданки +U та −U взаємно гинуть; лишаються опори периметра й сумарна ЕРС:
    //    рядок стає рівнянням  R1·I₁ + R3·I₂ = V.
    for (int c = 0; c < n; ++c) R[0][c] += R[1][c];
    V[0] += V[1];

    // 2) ОБМЕЖЕННЯ: звільнений рядок I₂ ← рівняння джерела  I₁ − I₂ = J.
    R[1][0] = +1.0;  R[1][1] = -1.0;  V[1] = J;

    if (!gauss_solve(n, R, V, I)) { printf("singular matrix\n"); return 1; }

    printf("I1 = %.1f мА,  I2 = %.1f мА\n", I[0] * 1e3, I[1] * 1e3);  // -> 45.0, 25.0
    return 0;
}
