struct Bucket { int rank; std::string key; std::string desc; };

class Scale {
public:
    Scale(std::string name, std::initializer_list<Bucket> buckets)
        : name_(std::move(name)) {
        for (const auto& b : buckets) {
            rank_[b.key]  = b.rank;
            desc_[b.rank] = b.desc;
        }
        std::string missing;
        for (int r = 1; r <= 10; ++r)
            if (!desc_.count(r))
                missing += (missing.empty() ? "" : ", ") + std::to_string(r);
        if (!missing.empty())
            throw std::invalid_argument(
                "шкала «" + name_ + "»: не описано кошики " + missing);
    }

    int operator()(const std::string& key) const {   // ім'я кошика → ранг
        auto it = rank_.find(key);
        if (it == rank_.end()) {
            std::string have;                          // std::map віддає імена по порядку
            for (const auto& kv : rank_)
                have += (have.empty() ? "" : ", ") + kv.first;
            throw std::out_of_range(
                "шкала «" + name_ + "»: немає кошика «" + key + "»; є " + have);
        }
        return it->second;
    }

    const std::string& desc(int rank) const { return desc_.at(rank); }

private:
    std::string name_;
    std::map<std::string, int> rank_;
    std::map<int, std::string> desc_;
};

const Scale SEVERITY("тяжкість", {
    {10, "шкода",       "шкода здоров'ю або безпеці"},
    {9,  "закон",       "порушення норм і приписів"},
    {8,  "втрата-осн",  "втрата основної функції"},
    {7,  "гірше-осн",   "основна функція працює гірше"},
    {6,  "втрата-друг", "втрата другорядної функції"},
    {5,  "гірше-друг",  "другорядна функція працює гірше"},
    {4,  "прикро",      "дуже неприємний вигляд, звук чи поведінка"},
    {3,  "помітно",     "помітна вада; більшість помічає"},
    {2,  "ледь",        "ледь помітна вада; помічають уважні"},
    {1,  "жодного",     "наслідку не видно"},
});

const Scale OCCURRENCE("частота", {
    {10, "1:10",    "≈ 100 на тисячу"},
    {9,  "1:20",    "50 на тисячу"},
    {8,  "1:50",    "20 на тисячу"},
    {7,  "1:100",   "10 на тисячу"},
    {6,  "1:500",   "2 на тисячу"},
    {5,  "1:2000",  "0.5 на тисячу"},
    {4,  "1:10к",   "0.1 на тисячу"},
    {3,  "1:100к",  "0.01 на тисячу"},
    {2,  "1:1млн",  "≤ 0.001 на тисячу"},
    {1,  "усунено", "причину усунено запобіжним контролем"},
});

const Scale DETECTION("виявність", {
    {10, "немає",     "контролю немає або він не здатен виявити"},
    {9,  "майже-ні",  "виявить хіба випадково"},
    {8,  "вибірково", "рідкісна ручна вибіркова перевірка"},
    {7,  "непрямо",   "непрямий контроль, уже після події"},
    {6,  "ручний",    "ручна перевірка кожного випадку"},
    {5,  "після",     "автоматичний контроль, але вже після наслідку"},
    {4,  "наступний", "автоматичний контроль на наступному кроці"},
    {3,  "на-місці",  "автоматичний контроль на місці, до наслідку"},
    {2,  "блокує",    "автоматичний контроль, що не пропускає далі"},
    {1,  "неможливо", "вид відмови неможливий за конструкцією"},
});
